# Keil uVision project Robot_FreeRTOS.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.6.4.0
  cpu: IRAM(0x20000000,0x080000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Robot_FreeRTOS +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=1 v6Lang=3 v6LangP=6
  c misc: @./via/rasc_armclang.via
  c include: .\Middle;.\USER_BSP;.\APP;.\MQTT;..\Robot_FreeRTOS
  asm misc: --via=./via/rasc_armasm.via
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_warmstart.c robot_thread_entry.c vision_service_thread_entry.c
  group APP
    ./APP/: robot.c robot.h robot_target.c robot_target.h robot_capture.c robot_capture.h robot_workflow.c robot_workflow.h robot_chassis_app.c robot_chassis_app.h
  group Middle
    ./Middle/: robot_cmd.c robot_cmd.h robot_kinematics.c robot_kinematics.h gripper.c gripper.h jetson_vision.c jetson_vision.h crc16.c crc16.h W800_mqtt.c W800_mqtt.h chassis.c chassis.h
  group MQTT
    ./MQTT/: esp8266.c esp8266.h MqttKit.c MqttKit.h cJSON.c cJSON.h onenet.c onenet.h
  group BSP
    ./USER_BSP/: bsp_can.c bsp_can.h bsp_led.c bsp_led.h bsp_laser.c bsp_laser.h Emm_V5.c Emm_V5.h bsp_uart.c bsp_uart.h bsp_usb_cdc.c bsp_usb_cdc.h usb_descriptor.c libemqtt.c libemqtt.h bsp_dht11.c bsp_dht11.h
software components: Flex Software:RA Configuration 1.0.0
